<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO-F072RB_RTC.ewp</path>
  </project>
  <batchBuild />
</workspace>
